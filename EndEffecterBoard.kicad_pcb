# Repository hosh0344/EndEffecterBoard2026

File README.md:

# EndEffecterBoard2026
## 概要

キャチロボ2026で用いるエンドエフェクタ基板

サーボモータ×3 & エアポンプ×3 & シリアルバスサーボ×1 を駆動可能

CAN, I2C, UARTの通信規格に対応

ABZエンコーダ読み取り

MCU: [STM32G431CBT6](https://www.stmcu.jp/stm32/stm32g4/stm32g4x1/66683/)

## KiCad design EndEffecterBoard.kicad_pcb

Parts:
C1, C22: 220u; CP_Radial_D8.0mm_P3.50mm
C7, C8, C10, C12, C13, C14, C15, C16, C23, C24, C25, C27, C28, C29: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C11: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: +3V3; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: 1N4148; D_SOD-123
D4: +5V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5, D11, D12: SS2040FL; D_SOD-123F
D6: +5VP; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D13: BATT; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: SWD; IDC-Header_2x05_P2.54mm_Vertical
J2: SW0; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3: SW1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: USB_C; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J5: +5V; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J6: I2C3; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J7: ENC; JST_XH_S5B-XH-A_1x05_P2.50mm_Horizontal
J8: SV1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J9: SV2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J10: SV3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J11: AIR1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J12: AIR2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J13: AIR3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J14: SerialServo; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical; LCSC x
J17: BATT; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
JP4: ID0; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP6: ID1; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
Q1: 2PB709AR; SOT-23-3; LCSC x
R1: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R9, R10: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R11: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R33, R34: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 7.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17: 20k; R_0603_1608Metric; LCSC C22787
R18, R19: 2.2k; R_0603_1608Metric; LCSC C22787
SW2: RESET; SW_SPST_PTS810
U2: CH340E; MSOP-10_3x3mm_P0.5mm; LCSC C99652
U3: TLV1117; SOT-223-3_TabPin2
U4: 74LVC2T45DC; VSSOP-8_2.3x2mm_P0.5mm
U5: ADuM121N; SOIC-8_3.9x4.9mm_P1.27mm; LCSC x
U6: MAX485E; SOIC-8_3.9x4.9mm_P1.27mm; LCSC x
U14: STM32G431CBTx; LQFP-48_7x7mm_P0.5mm
Y2: 16MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm_HandSoldering

Connections:
+3V3: C7.2, C10.1, C11.1, C12.1, C14.1, C23.2, C24.2, C27.2, C28.2, C29.2, D3.2 (A), D5.1 (K), R6.1, R7.1, R8.1, R33.2, U2.7 (VCC), U2.10 (V3), U3.2 (VO), U4.1 (VCCA), U5.1 (VDD1), U14.1 (VBAT), U14.21 (VDDA), U14.24 (VDD), U14.36 (VDD), U14.48 (VDD); also elsewhere on the board
+5V: C8.1, C9.1, C13.1, D3.1 (K), D11.1 (K), D12.1 (K), J7.4, R9.1, U3.3 (VI), U4.8 (VCCB); also elsewhere on the board
+5VP: C15.1, C16.1, C22.1, J5.2, J8.2, J9.2, J10.2, Q1.2 (E), R10.1, R18.1, U5.8 (VDD2), U6.8 (VCC); also elsewhere on the board
+BATT: C1.1, J14.2, J17.2, R1.1
/A: J7.3, U4.6 (2B)
/AIR/OUTPUT1: J11.2; also elsewhere on the board
/AIR/OUTPUT2: J12.2; also elsewhere on the board
/AIR/OUTPUT3: J13.2; also elsewhere on the board
/B: J7.5, U4.7 (1B)
/BOOT0: R34.2, U14.45 (PB8)
/CAN1/CAN_RX: U14.33 (PA11); also elsewhere on the board
/CAN1/CAN_TX: U14.34 (PA12); also elsewhere on the board
/NRST: C25.2, J1.1, R33.1, SW2.2, U14.7 (PG10)
/SWCLK: J1.2, U14.38 (PA14)
/SWDIO: J1.4, U14.37 (PA13)
/Servo/OUTPUT1: J8.3; also elsewhere on the board
/Servo/OUTPUT2: J9.3; also elsewhere on the board
/Servo/OUTPUT3: J10.3; also elsewhere on the board
/USART1_RX: U5.2 (VOA), U14.32 (PA10)
/USART1_TX: U5.3 (VIB), U14.31 (PA9)
/USART2_RX: U2.8 (TXD), U14.11 (PA3)
/USART2_TX: U2.9 (RXD), U14.10 (PA2)
/X: J7.2, R12.1
AIR1: U14.26 (PB12); also elsewhere on the board
AIR2: U14.27 (PB13); also elsewhere on the board
AIR3: U14.28 (PB14); also elsewhere on the board
ENC_X: R11.1, R12.2, U14.12 (PA4)
GND: C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C23.1, C24.1, C25.1, C27.1, C28.1, C29.1, D1.1 (K), D2.1 (K), D4.1 (K), J1.5, J1.6, J2.1, J3.1, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), J6.1, J7.1, JP4.1 (A), JP6.1 (A), R2.2, R3.2, R11.2, R34.1, SW2.1, U2.3 (GND), U3.1 (GND), U4.4 (GND), U4.5 (DIR), U5.4 (GND1), U14.19 (VSSA), U14.23 (VSS), U14.35 (VSS), U14.47 (VSS), Y2.2; also elsewhere on the board
GNDPWR: C1.2, C15.2, C16.2, C22.2, D6.1 (K), D13.1 (K), J5.1, J8.1, J9.1, J10.1, J11.1, J12.1, J13.1, J14.3, J17.1, R17.2, R19.2, U5.5 (GND2), U6.5 (GND); also elsewhere on the board
I2C3_SCL: J6.2, R8.2, U14.30 (PA8)
I2C3_SDA: J6.3, R7.2, U14.42 (PB5)
LED: R5.1, U14.2 (PC13)
LIM_SW1: J2.2, U14.22 (PB10)
LIM_SW2: J3.2, U14.25 (PB11)
unnamed: D1.2 (A), R5.2
unnamed: D2.2 (A), R6.2
unnamed: D4.2 (A), R9.2
unnamed: D5.2 (A), J6.4
unnamed: D6.2 (A), R10.2
unnamed: D11.2 (A), J1.9, J1.10
unnamed: D12.2 (A), J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS)
unnamed: D13.2 (A), R1.2
unnamed: J4.A5 (CC1), R2.1
unnamed: J4.B5 (CC2), R3.1
unnamed: J14.1, U6.6 (A)
unnamed: JP4.2 (B), U14.17 (PB1)
unnamed: JP6.2 (B), U14.18 (PB2)
unnamed: Q1.1 (B), R16.2
unnamed: Q1.3 (C), R17.1, U6.2 (~RE), U6.3 (DE)
unnamed: J4.A6 (D+), J4.B6 (D+), U2.1 (UD+)
unnamed: J4.A7 (D-), J4.B7 (D-), U2.2 (UD-)
unnamed: U5.7 (VIA), U6.1 (RO)
unnamed: R16.1, U5.6 (VOB), U6.4 (DI)
unnamed: R18.2, R19.1, U6.7 (B)
unnamed: U14.5 (PF0), Y2.1
unnamed: U14.6 (PF1), Y2.3
TIM2_CH1: U4.3 (2A), U14.8 (PA0)
TIM2_CH2: U4.2 (1A), U14.9 (PA1)
TIM3_CH1: U14.14 (PA6); also elsewhere on the board
TIM3_CH2: U14.15 (PA7); also elsewhere on the board
TIM3_CH3: U14.16 (PB0); also elsewhere on the board

Notes on the sheet:
MCU
LED
TIM2: Encoder
Servo Motor
Connectivity
USB-UART
Air Pump
Serial Bus Servo
TIM3: Servo Motor
エンコーダ信号レベル変換(5V→3.3V)

Parts:
D8, D9, D10: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R24, R25, R27, R28, R30, R31: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R26, R29, R32: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U11, U12, U13: TLP172AM; Toshiba_SOIC-4-6_4.4x3.6mm_P1.27mm

Connections:
+5VP: U11.6, U12.6, U13.6; also elsewhere on the board
/AIR/OUTPUT1: R26.1, U11.4; also elsewhere on the board
/AIR/OUTPUT2: R29.1, U12.4; also elsewhere on the board
/AIR/OUTPUT3: R32.1, U13.4; also elsewhere on the board
AIR1: R24.1, R25.2; also elsewhere on the board
AIR2: R27.1, R28.2; also elsewhere on the board
AIR3: R30.1, R31.2; also elsewhere on the board
GND: D8.1 (K), D9.1 (K), D10.1 (K), U11.3, U12.3, U13.3; also elsewhere on the board
GNDPWR: R26.2, R29.2, R32.2; also elsewhere on the board
unnamed: D8.2 (A), R24.2
unnamed: D9.2 (A), R27.2
unnamed: D10.2 (A), R30.2
unnamed: R25.1, U11.1
unnamed: R28.1, U12.1
unnamed: R31.1, U13.1

Parts:
C19, C20, C21: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R21, R22, R23: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U8, U9, U10: TLP2348; U_SO6_11-4L1S_TOS

Connections:
+3V3: U8.1 (A), U9.1 (A), U10.1 (A); also elsewhere on the board
+5VP: C19.2, C20.2, C21.2, U8.6 (VDD), U9.6 (VDD), U10.6 (VDD); also elsewhere on the board
/Servo/OUTPUT1: U8.5 (VO); also elsewhere on the board
/Servo/OUTPUT2: U9.5 (VO); also elsewhere on the board
/Servo/OUTPUT3: U10.5 (VO); also elsewhere on the board
GNDPWR: C19.1, C20.1, C21.1, U8.4 (GND), U9.4 (GND), U10.4 (GND); also elsewhere on the board
unnamed: R21.2, U8.3 (K)
unnamed: R22.2, U9.3 (K)
unnamed: R23.2, U10.3 (K)
TIM3_CH1: R21.1; also elsewhere on the board
TIM3_CH2: R22.1; also elsewhere on the board
TIM3_CH3: R23.1; also elsewhere on the board

Parts:
C17, C18: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J15, J16: CAN; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
JP3: TR; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R20: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U7: ATA6561; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C17.2, U7.5 (Vio); also elsewhere on the board
+5V: C18.2, J15.4, J16.4, U7.3 (VDD); also elsewhere on the board
/CAN1/CANH: J15.3, J16.3, JP3.2 (B), U7.7 (CANH)
/CAN1/CANL: J15.2, J16.2, R20.2, U7.6 (CANL)
/CAN1/CAN_RX: U7.4 (RXD); also elsewhere on the board
/CAN1/CAN_TX: U7.1 (TXD); also elsewhere on the board
GND: C17.1, C18.1, J15.1, J16.1, U7.2 (VSS), U7.8 (STBY); also elsewhere on the board
unnamed: JP3.1 (A), R20.1

Board: 2 copper layers, 80.0 x 60.0 mm, 101 parts (58 on the bottom side), 73 nets.
